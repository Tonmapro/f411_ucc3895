#include <stddef.h>
#include <string.h>
#include "ui_manager.h"
#include "oled_ssd1306.h"
#include "config.h"
#include "mma_fsm.h"
#include "encoder.h"
#include "signal_processing.h"

/* ========================================================================== */
/*               ВНЕШНИЕ ПЕРЕМЕННЫЕ УПРАВЛЕНИЯ ИЗ МОДУЛЯ WELDER               */
/* ========================================================================== */
extern uint32_t current_selected_mode; // 0 = MMA, 1 = TIG
extern uint8_t  ui_edit_target;        // 0 = Регулируем Ток, 1 = Регулируем Вольты

/* Локальная структура-снимок для защиты от гонки данных с прерыванием АЦП */
static Inverter_DataType ui_data_snap; 
static uint32_t ms_counter = 0U;
static uint32_t ui_frame_counter = 0U; /* Кадровый счётчик для мигания (не зависит от SysTick) */

/* ========================================================================== */
/*          ГРАФИЧЕСКИЕ ШРИФТЫ (ПЕРЕНЕСЕНЫ ИЗ ВАШИХ ИСХОДНЫХ ФАЙЛОВ)          */
/* ========================================================================== */

#include "ui_font.h"

// Массив стандартного шрифта 8x16 (ASCII коды 32-126)
static const uint8_t Font_8x16[95][16] = {
    // Вставьте сюда полные битовые массивы Font_8x16 из страниц 4-7 вашего display.c

    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // пробел (32)
    {0x00,0x00,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x00,0x00,0x0C,0x0C,0x00,0x00,0x00}, // !
    {0x00,0x24,0x24,0x24,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // "
    {0x00,0x00,0x24,0x24,0x7E,0x24,0x24,0x7E,0x24,0x24,0x00,0x00,0x00,0x00,0x00,0x00}, // #
    {0x00,0x00,0x08,0x3E,0x28,0x28,0x1C,0x0A,0x0A,0x3E,0x08,0x08,0x00,0x00,0x00,0x00}, // $
    {0x00,0x00,0x00,0x44,0x24,0x10,0x08,0x04,0x22,0x22,0x00,0x00,0x00,0x00,0x00,0x00}, // %
    {0x00,0x00,0x18,0x24,0x24,0x18,0x24,0x44,0x44,0x3A,0x00,0x00,0x00,0x00,0x00,0x00}, // &
    {0x00,0x00,0x0C,0x0C,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '
    {0x00,0x00,0x04,0x08,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x08,0x04,0x00}, // (
    {0x00,0x00,0x20,0x10,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x10,0x20,0x00}, // )
    {0x00,0x00,0x00,0x10,0x54,0x38,0x10,0x38,0x54,0x10,0x00,0x00,0x00,0x00,0x00,0x00}, // *
    {0x00,0x00,0x00,0x08,0x08,0x08,0x3E,0x08,0x08,0x08,0x00,0x00,0x00,0x00,0x00,0x00}, // +
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x04,0x08,0x00}, // ,
    {0x00,0x00,0x00,0x00,0x00,0x00,0x3E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // -
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x00,0x00,0x00}, // .
    {0x00,0x00,0x40,0x20,0x20,0x10,0x10,0x08,0x08,0x04,0x04,0x02,0x02,0x00,0x00,0x00}, // /
    {0x00,0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // 0 (48)
    {0x00,0x00,0x08,0x18,0x28,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x3E,0x00,0x00,0x00}, // 1
    {0x00,0x00,0x3C,0x42,0x42,0x02,0x04,0x08,0x10,0x20,0x42,0x42,0x7E,0x00,0x00,0x00}, // 2
    {0x00,0x00,0x3C,0x42,0x42,0x02,0x04,0x18,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00}, // 3
    {0x00,0x00,0x04,0x0C,0x14,0x24,0x44,0x44,0x44,0x7E,0x04,0x04,0x1E,0x00,0x00,0x00}, // 4
    {0x00,0x00,0x7E,0x40,0x40,0x40,0x5C,0x62,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00}, // 5
    {0x00,0x00,0x3C,0x42,0x40,0x40,0x5C,0x62,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // 6
    {0x00,0x00,0x7E,0x42,0x02,0x04,0x04,0x08,0x08,0x10,0x10,0x10,0x10,0x00,0x00,0x00}, // 7
    {0x00,0x00,0x3C,0x42,0x42,0x42,0x3C,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // 8
    {0x00,0x00,0x3C,0x42,0x42,0x42,0x42,0x3E,0x02,0x02,0x02,0x42,0x3C,0x00,0x00,0x00}, // 9
    {0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x00,0x00,0x00,0x00,0x0C,0x0C,0x00,0x00,0x00}, // :
    {0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x00,0x00,0x00,0x00,0x0C,0x0C,0x04,0x08,0x00}, // ;
    {0x00,0x00,0x02,0x04,0x08,0x10,0x20,0x40,0x20,0x10,0x08,0x04,0x02,0x00,0x00,0x00}, // <
    {0x00,0x00,0x00,0x00,0x00,0x3E,0x00,0x00,0x00,0x3E,0x00,0x00,0x00,0x00,0x00,0x00}, // =
    {0x00,0x00,0x40,0x20,0x10,0x08,0x04,0x02,0x04,0x08,0x10,0x20,0x40,0x00,0x00,0x00}, // >
    {0x00,0x00,0x3C,0x42,0x42,0x02,0x04,0x08,0x08,0x00,0x00,0x08,0x08,0x00,0x00,0x00}, // ?
    {0x00,0x00,0x3C,0x42,0x42,0x5E,0x52,0x52,0x52,0x4E,0x40,0x42,0x3C,0x00,0x00,0x00}, // @
    {0x00,0x00,0x18,0x24,0x24,0x42,0x42,0x7E,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // A (65)
    {0x00,0x00,0x7C,0x22,0x22,0x22,0x3C,0x22,0x22,0x22,0x22,0x22,0x7C,0x00,0x00,0x00}, // B
    {0x00,0x00,0x3C,0x42,0x42,0x40,0x40,0x40,0x40,0x40,0x42,0x42,0x3C,0x00,0x00,0x00}, // C
    {0x00,0x00,0x78,0x24,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x24,0x78,0x00,0x00,0x00}, // D
    {0x00,0x00,0x7E,0x42,0x40,0x40,0x7C,0x40,0x40,0x40,0x40,0x42,0x7E,0x00,0x00,0x00}, // E
    {0x00,0x00,0x7E,0x42,0x40,0x40,0x7C,0x40,0x40,0x40,0x40,0x40,0x40,0x00,0x00,0x00}, // F
    {0x00,0x00,0x3C,0x42,0x42,0x40,0x40,0x4E,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // G
    {0x00,0x00,0x42,0x42,0x42,0x42,0x7E,0x42,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // H
    {0x00,0x00,0x3E,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x3E,0x00,0x00,0x00}, // I
    {0x00,0x00,0x0F,0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00}, // J
    {0x00,0x00,0x44,0x48,0x50,0x60,0x50,0x48,0x44,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // K
    {0x00,0x00,0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x42,0x7E,0x00,0x00,0x00}, // L
    {0x00,0x00,0x42,0x66,0x5A,0x5A,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // M
    {0x00,0x00,0x42,0x62,0x52,0x52,0x4A,0x46,0x42,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // N
    {0x00,0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // O
    {0x00,0x00,0x7C,0x22,0x22,0x22,0x3C,0x40,0x40,0x40,0x40,0x40,0x40,0x00,0x00,0x00}, // P
    {0x00,0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x4A,0x44,0x3A,0x00,0x00,0x00}, // Q
    {0x00,0x00,0x7C,0x22,0x22,0x22,0x3C,0x50,0x48,0x44,0x42,0x42,0x42,0x00,0x00,0x00}, // R
    {0x00,0x00,0x3C,0x42,0x42,0x40,0x3C,0x02,0x02,0x02,0x42,0x42,0x3C,0x00,0x00,0x00}, // S
    {0x00,0x00,0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00}, // T
    {0x00,0x00,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00}, // U
    {0x00,0x00,0x42,0x42,0x42,0x42,0x24,0x24,0x24,0x14,0x14,0x08,0x08,0x00,0x00,0x00}, // V
    {0x00,0x00,0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x4A,0x5A,0x66,0x42,0x00,0x00,0x00}, // W
    {0x00,0x00,0x42,0x42,0x24,0x24,0x14,0x08,0x14,0x24,0x24,0x42,0x42,0x00,0x00,0x00}, // X
    {0x00,0x00,0x42,0x42,0x24,0x24,0x14,0x08,0x08,0x08,0x08,0x08,0x08,0x00,0x00,0x00}, // Y
    {0x00,0x00,0x7E,0x42,0x02,0x04,0x08,0x10,0x20,0x40,0x40,0x42,0x7E,0x00,0x00,0x00}, // Z
    {0x00,0x00,0x1C,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x1C,0x00}, // [
    {0x00,0x00,0x02,0x02,0x04,0x04,0x08,0x08,0x10,0x10,0x20,0x20,0x40,0x40,0x00,0x00}, 
    {0x00,0x00,0x38,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x38,0x00}, // ]
    {0x00,0x00,0x08,0x14,0x22,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ^
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7E,0x00}, // _
    {0x00,0x00,0x10,0x08,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // `
    // Дальше в массиве закодированы строчные буквы (a-z) и спецсимволы (коды 97-126)
    {0x00,0x00,0x00,0x00,0x00,0x3C,0x02,0x3E,0x42,0x42,0x46,0x3A,0x00,0x00,0x00,0x00}, // a
    {0x00,0x00,0x40,0x40,0x40,0x7C,0x22,0x22,0x22,0x22,0x22,0x7C,0x00,0x00,0x00,0x00}, // b
    {0x00,0x00,0x00,0x00,0x00,0x3C,0x42,0x40,0x40,0x40,0x42,0x3C,0x00,0x00,0x00,0x00}, // c
    {0x00,0x00,0x02,0x02,0x02,0x3E,0x42,0x42,0x42,0x46,0x3A,0x00,0x00,0x00,0x00,0x00}, // d
    {0x00,0x00,0x00,0x00,0x00,0x3C,0x42,0x7E,0x40,0x40,0x42,0x3C,0x00,0x00,0x00,0x00}, // e
    {0x00,0x00,0x1C,0x22,0x20,0x20,0x78,0x20,0x20,0x20,0x20,0x20,0x70,0x00,0x00,0x00}, // f
    {0x00,0x00,0x00,0x00,0x00,0x3E,0x42,0x42,0x42,0x3E,0x02,0x02,0x3C,0x00,0x00,0x00}, // g
    {0x00,0x00,0x40,0x40,0x40,0x7C,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x00,0x00,0x00}, // h
    {0x00,0x00,0x08,0x08,0x00,0x18,0x08,0x08,0x08,0x08,0x08,0x08,0x1C,0x00,0x00,0x00}, // i
    {0x00,0x00,0x02,0x02,0x00,0x06,0x02,0x02,0x02,0x02,0x02,0x42,0x3C,0x00,0x00,0x00}, // j
    {0x00,0x00,0x40,0x40,0x40,0x44,0x48,0x50,0x60,0x50,0x48,0x44,0x42,0x00,0x00,0x00}, // k
    {0x00,0x00,0x18,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x1C,0x00,0x00,0x00}, // l
    {0x00,0x00,0x00,0x00,0x00,0x7C,0x52,0x4A,0x4A,0x42,0x42,0x42,0x42,0x00,0x00,0x00}, // m
    {0x00,0x00,0x00,0x00,0x00,0x7C,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x00,0x00,0x00}, // n
    {0x00,0x00,0x00,0x00,0x00,0x3C,0x42,0x42,0x42,0x42,0x42,0x3C,0x00,0x00,0x00,0x00}, // o
    {0x00,0x00,0x00,0x00,0x00,0x7C,0x22,0x22,0x22,0x7C,0x40,0x40,0x40,0x00,0x00,0x00}, // p
    {0x00,0x00,0x00,0x00,0x00,0x3E,0x42,0x42,0x42,0x3E,0x02,0x02,0x02,0x00,0x00,0x00}, // q
    {0x00,0x00,0x00,0x00,0x00,0x7C,0x22,0x20,0x20,0x20,0x20,0x20,0x70,0x00,0x00,0x00}, // r
    {0x00,0x00,0x00,0x00,0x00,0x3C,0x42,0x30,0x0E,0x02,0x42,0x3C,0x00,0x00,0x00,0x00}, // s
    {0x00,0x00,0x20,0x20,0x20,0x78,0x20,0x20,0x20,0x20,0x22,0x22,0x1C,0x00,0x00,0x00}, // t
    {0x00,0x00,0x00,0x00,0x00,0x42,0x42,0x42,0x42,0x42,0x46,0x3A,0x00,0x00,0x00,0x00}, // u
    {0x00,0x00,0x00,0x00,0x00,0x42,0x42,0x24,0x24,0x14,0x14,0x08,0x08,0x00,0x00,0x00}, // v
    {0x00,0x00,0x00,0x00,0x00,0x42,0x42,0x42,0x4A,0x5A,0x66,0x42,0x00,0x00,0x00,0x00}, // w
    {0x00,0x00,0x00,0x00,0x00,0x42,0x24,0x14,0x08,0x14,0x24,0x42,0x00,0x00,0x00,0x00}, // x
    {0x00,0x00,0x00,0x00,0x00,0x42,0x42,0x42,0x42,0x3E,0x02,0x02,0x3C,0x00,0x00,0x00}, // y
    {0x00,0x00,0x00,0x00,0x00,0x7E,0x04,0x08,0x10,0x20,0x42,0x7E,0x00,0x00,0x00,0x00}, // z
    {0x00,0x00,0x0C,0x10,0x10,0x10,0x08,0x10,0x20,0x10,0x08,0x10,0x10,0x10,0x0C,0x00}, // {
    {0x00,0x00,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08}, // |
    {0x00,0x00,0x30,0x08,0x08,0x08,0x10,0x08,0x04,0x08,0x10,0x08,0x08,0x08,0x30,0x00}, // }
    {0x00,0x00,0x00,0x00,0x00,0x32,0x4C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}  // ~ (126)
    
};

/* ========================================================================== */
/*                       НИЗКОУРОВНЕВЫЕ ГРАФИЧЕСКИЕ ПРИМИТИВЫ                 */
/* ========================================================================== */

/**
 * @brief Попиксельная отрисовка строго в текущий скрытый буфер (Back Buffer)
 */
static void UI_DrawPixel_BackBuf(int x, int y, uint8_t color) {
    if (x < 0 || x >= (int)SSD1306_WIDTH || y < 0 || y >= (int)SSD1306_HEIGHT) return;
    
    // Получаем адрес буфера, в котором сейчас идет рендеринг в ОЗУ
    uint8_t *back_buf = OLED_Get_BackBuffer_Ptr();
    if (back_buf == NULL) return;

    if (color) {
        back_buf[x + (y / 8) * SSD1306_WIDTH] |= (1 << (y % 8));
    } else {
        back_buf[x + (y / 8) * SSD1306_WIDTH] &= ~(1 << (y % 8));
    }
}

/**
 * @brief Высокоскоростная отрисовка горизонтальной разделительной линии
 */
static void UI_DrawHorizontalLine(int x1, int x2, int y, uint8_t color) {
    if (x1 < 0) x1 = 0;
    if (x2 >= (int)SSD1306_WIDTH) x2 = (int)SSD1306_WIDTH - 1;
    
    for (int x = x1; x <= x2; x++) {
        UI_DrawPixel_BackBuf(x, y, color);
    }
}

/**
 * @brief Отрисовка символа стандартного шрифта 8х16
 */
static void UI_DrawChar_8x16(int x, int y, char c, uint8_t color) {
    if (c < 32 || c > 126) return; 
    uint8_t font_idx = c - 32; // Смещение относительно пробела в ASCII

    for (int row = 0; row < 16; row++) {
        uint8_t line_bits = Font_8x16[font_idx][row]; 
        for (int col = 0; col < 8; col++) {
            if (line_bits & (0x80 >> col)) {
                UI_DrawPixel_BackBuf(x + col, y + row, color);
            } else {
                UI_DrawPixel_BackBuf(x + col, y + row, !color); // Очистка фона (инверсия)
            }
        }
    }
}

/**
 * @brief Вывод строки текста стандартным шрифтом 8х16
 */
static void UI_PrintStr_8x16(int x, int y, const char* str, uint8_t color) {
    while (*str) {
        UI_DrawChar_8x16(x, y, *str, color);
        x += 8; // Шаг строго 8 пикселей
        str++;
    }
}

/* Компактная строка 8x8: объединяем пары строк существующего шрифта.
   Выделенная область y=56..63 не пересекается со статусом y=40..55. */
static void UI_PrintDiag(int x, const char* str) {
    while (*str) {
        unsigned char c = (unsigned char)*str++;
        if (c >= 32U && c <= 126U) {
            for (int row = 0; row < 8; row++) {
                uint8_t bits = Font_8x16[c - 32U][row * 2] |
                               Font_8x16[c - 32U][row * 2 + 1];
                for (int col = 0; col < 8; col++) {
                    UI_DrawPixel_BackBuf(x + col, 56 + row,
                                         (bits & (0x80U >> col)) ? 1U : 0U);
                }
            }
        }
        x += 8;
    }
}

/* Shared sans bitmap: alarms 16x32, current digits 24x32. */
static void UI_DrawScaledChar(int x, int y, char c, int sx, int sy) {
    if (c >= 'a' && c <= 'z') c -= 'a' - 'A';
    const char *entry = c ? strchr(UI_FontChars, c) : NULL;
    unsigned idx = entry ? (unsigned)(entry - UI_FontChars) : 16U;
    for (int row = 0; row < 16 * sy; row++) {
        uint8_t bits = UI_Font[idx][row / sy];
        for (int col = 0; col < 8 * sx; col++) {
            UI_DrawPixel_BackBuf(x + col, y + row,
                                 (bits & (0x80U >> (col / sx))) ? 1U : 0U);
        }
    }
}

static void UI_DrawBigChar(int x, int y, char c) {
    UI_DrawScaledChar(x, y, c, 2, 2);
}

/* Ink bounding box (first/last lit column) of a glyph in the shared font;
   blank glyph (space or unknown) yields left > right. */
static void UI_GlyphInk(char c, int *left, int *right) {
    if (c >= 'a' && c <= 'z') c -= 'a' - 'A';
    const char *entry = c ? strchr(UI_FontChars, c) : NULL;
    unsigned idx = entry ? (unsigned)(entry - UI_FontChars) : 16U;
    *left = 8;
    *right = -1;
    for (int row = 0; row < 16; row++)
        for (int col = 0; col < 8; col++)
            if (UI_Font[idx][row] & (0x80U >> col)) {
                if (col < *left) *left = col;
                if (col > *right) *right = col;
            }
}

/* Optical layout: constant gap between glyph INK edges. Fixed pitch leaves
   wide holes around narrow glyphs ('1', '!'), so spacing is measured on lit
   pixels instead. xs[] receives per-glyph draw offsets relative to the
   block's left ink edge; returns the total ink width. */
static int UI_LayoutInk(const char *str, int sx, int gap, int *xs) {
    int ink = 0;
    for (int i = 0; str[i]; i++) {
        int l, r;
        UI_GlyphInk(str[i], &l, &r);
        if (r < 0) { xs[i] = ink; ink += 6 * sx + gap; continue; }
        xs[i] = ink - l * sx;
        ink += (r - l + 1) * sx + gap;
    }
    return ink > gap ? ink - gap : 0;
}

/* Center all alarms; TSENSOR occupies 124 pixels. */
static void UI_PrintBigStr(int y, const char* str) {
    int width = (int)strlen(str) * 18 - 2;
    int x = ((int)SSD1306_WIDTH - width) / 2;
    while (*str) {
        UI_DrawBigChar(x, y, *str++);
        x += 18;
    }
}

/* Setpoint, not measured current. Digits 24x32 with an even 4 px ink gap,
   unit 'A' 16x32 on the same top/bottom lines, 8 px after the last digit. */
static void UI_PrintCurrent(int current) {
    if (current < 0) current = 0;
    if (current > 999) current = 999;
    char digits[4] = {(char)('0' + current / 100),
                      (char)('0' + (current / 10) % 10),
                      (char)('0' + current % 10), '\0'};
    const char *p = digits;
    while (*p == '0' && p[1]) p++;
    int xs[3], al, ar;
    int width = UI_LayoutInk(p, 3, 4, xs);
    UI_GlyphInk('A', &al, &ar);
    int total = width + 8 + (ar - al + 1) * 2;
    int x = ((int)SSD1306_WIDTH - total) / 2;
    for (int i = 0; p[i]; i++)
        UI_DrawScaledChar(x + xs[i], 2, p[i], 3, 2);
    UI_DrawScaledChar(x + width + 8 - al * 2, 2, 'A', 2, 2);
}

/* ========================================================================== */
/*                           ГЛАВНЫЕ ИНТЕРФЕЙСНЫЕ ФУНКЦИИ                     */
/* ========================================================================== */

void UI_Manager_Init(void) {
    OLED_Init(); // Инициализация двубуферного драйвера дисплея
}

void UI_Manager_Update(void) {
    ms_counter = System_Get_Tick(); // Получаем системное время (SysTick, 1 мс)
    ui_frame_counter++;             // Кадровый счётчик (растёт всегда)

    /* 1. ЗАЩИТА ШИНЫ: Если DMA сейчас занят выталкиванием старого кадра, выходим */
    if (OLED_GetStatus() == OLED_BUSY_DMA) {
        return;
    }

    /* 2. ОЧИСТКА: Обнуляем теневой (Back) буфер ОЗУ через memset за 1 такт */
    OLED_Clear(OLED_COLOR_BLACK);

    /* 3. АТОМАРНЫЙ СНИМОК: Копируем данные из быстрого прерывания FSM (20 кГц) */
    ui_data_snap.target_current = Inverter.target_current;
    ui_data_snap.actual_voltage = Inverter.actual_voltage;
    ui_data_snap.state          = Inverter.state;
    ui_data_snap.fault_code     = Inverter.fault_code;

    /* ========================================================================== */
    /* ЗОНА 1 (Верхняя, Y = 2): Крупный Ток уставки или Мигающий Экран Аварии     */
    /* ========================================================================== */
    if (ui_data_snap.state == SYS_STATE_FAULT) {
        /* Мигание ошибки: каждый чётный 50-кадровый интервал текст виден,
           нечётный — скрыт. Надёжно работает независимо от SysTick. */
        if ((ui_frame_counter & 0x20U) == 0U) {
            switch (ui_data_snap.fault_code) {
                case FAULT_CODE_OVERCURRENT:  UI_PrintBigStr(2, "SHORT!");  break;
                case FAULT_CODE_LOW_15V:      UI_PrintBigStr(2, "220V-!");  break;
                case FAULT_CODE_OVERHEAT_IGBT:
                case FAULT_CODE_OVERHEAT_DIO: UI_PrintBigStr(2, "HOT!!");  break;
                case FAULT_CODE_FAN_BLOCKED:  UI_PrintBigStr(2, "FAN ER");  break;
                case FAULT_CODE_SENSOR_OPEN:  UI_PrintBigStr(2, "TSENSOR"); break;
                default:                      UI_PrintBigStr(2, "ERROR");  break;
            }
        }
    } else {
        UI_PrintCurrent((int)ui_data_snap.target_current);
    }

    /* РАЗДЕЛИТЕЛЬНАЯ ГЕОМЕТРИЧЕСКАЯ ЛИНИЯ */
    UI_DrawHorizontalLine(0, 127, 37, 1);

    /* ========================================================================== */
    /* ЗОНА 2 (Нижняя, Y = 40): Информационный бар мелким шрифтом 8x16            */
    /* ========================================================================== */
    char bar_buff[8];

    // --- ПОДЗОНА 2.1: Левый угол (X = 4) -> Настраиваемая уставка тока или вольт ХХ ---
    if (current_selected_mode == 1) {
        int cur_set = (int)ui_data_snap.target_current;
        bar_buff[0] = (cur_set / 100) + '0';
        bar_buff[1] = ((cur_set % 100) / 10) + '0';
        bar_buff[2] = (cur_set % 10) + '0';
        bar_buff[3] = 'A';
        bar_buff[4] = '\0';

        if (bar_buff[0] == '0') UI_PrintStr_8x16(4, 40, &bar_buff[1], 1);
        else UI_PrintStr_8x16(4, 40, bar_buff, 1);
    } else {
        if (ui_edit_target == 0) {
            int cur_set = (int)ui_data_snap.target_current;
            bar_buff[0] = (cur_set / 100) + '0';
            bar_buff[1] = ((cur_set % 100) / 10) + '0';
            bar_buff[2] = (cur_set % 10) + '0';
            bar_buff[3] = 'A';
            bar_buff[4] = '\0';

            if (bar_buff[0] == '0') UI_PrintStr_8x16(4, 40, &bar_buff[1], 1);
            else UI_PrintStr_8x16(4, 40, bar_buff, 1);
        } else {
            bar_buff[0] = '7';
            bar_buff[1] = '5';
            bar_buff[2] = '.';
            bar_buff[3] = '0';
            bar_buff[4] = 'V';
            bar_buff[5] = '\0';

            UI_PrintStr_8x16(4, 40, bar_buff, 1);
        }
    }

    // --- ПОДЗОНА 2.2: Центр (X = 52) -> Реальное измеряемое напряжение дуги из АЦП ---
    uint32_t volt_meas = (((uint32_t)ui_data_snap.actual_voltage * 1000U) + 2048U) / 4096U;
    if (volt_meas > 999U) volt_meas = 999U;

    char meas_buff[8];
    meas_buff[0] = (volt_meas / 100) + '0';
    meas_buff[1] = ((volt_meas % 100) / 10) + '0';
    meas_buff[2] = '.';
    meas_buff[3] = (volt_meas % 10) + '0';
    meas_buff[4] = 'V';
    meas_buff[5] = '\0';

    UI_PrintStr_8x16(52, 40, meas_buff, 1);

    // --- ПОДЗОНА 2.3: Правый угол (X = 96) -> Маркер выбранного режима MMA/TIG ---
    if (current_selected_mode == 0) {
        UI_PrintStr_8x16(96, 40, "MMA", 1);
    } else {
        UI_PrintStr_8x16(96, 40, "TIG", 1);
    }

    // --- ДИАГНОСТИКА (V14): 7 чередующихся фаз (~0.35 с каждая, кадровый счётчик) ---
    // Ф0: V14 xx:x  — версия прошивки + состояние + fault_code
    // Ф1: Dnnn     — цифровой уровень падов PA2/PA3/PA5 из IDR (неинформативен в ANALOG)
    // Ф2: Annnn    — код канала PA3 (NTC IGBT)
    // Ф3: Bnnnn    — код канала PA5 (NTC диодов)
    // Ф4: Fnnnn    — код тока кулера PB0: <40 обрыв (продувка!), >3500 клин
    // Ф5: Ennnn    — код канала +15В (PA2): <700 → «220V-!»
    // Ф6: Mnnnnn   — миллисекунды SysTick: счёт ДОЛЖЕН расти.
    char st_dbg[10];
    const char *hex_tbl = "0123456789ABCDEF";
    switch ((ui_frame_counter >> 8) % 7U) {
    case 0:
        st_dbg[0] = 'V';
        st_dbg[1] = hex_tbl[(FW_BUILD / 10U) % 10U];   /* десятки версии (V10, V11) */
        st_dbg[2] = hex_tbl[FW_BUILD % 10U];           /* единицы версии */
        st_dbg[3] = ' ';
        st_dbg[4] = hex_tbl[(ui_data_snap.state >> 4) & 0xF];
        st_dbg[5] = hex_tbl[ui_data_snap.state & 0xF];
        st_dbg[6] = ':';
        st_dbg[7] = hex_tbl[ui_data_snap.fault_code & 0xF];
        st_dbg[8] = '\0';
        break;
    case 1: {
        uint32_t idr = GPIOA->IDR;
        st_dbg[0] = 'D';
        st_dbg[1] = (char)('0' + ((idr >> 2) & 1U)); /* PA2: +15В (ANALOG, без подтяжки) */
        st_dbg[2] = (char)('0' + ((idr >> 3) & 1U)); /* PA3: NTC IGBT  (ANALOG, без подтяжки)  */
        st_dbg[3] = (char)('0' + ((idr >> 5) & 1U)); /* PA5: NTC диоды (ANALOG, без подтяжки)  */
        st_dbg[4] = '\0';
        break;
    }
    case 2: {
        uint16_t a_cur = (uint16_t)(Signal_Processing_Get_Filtered_Code(ADC_TEMP_IDX) + 0.5f);
        if (a_cur > 9999U) a_cur = 9999U;
        st_dbg[0] = 'A';
        st_dbg[1] = (char)('0' + (a_cur / 1000U) % 10U);
        st_dbg[2] = (char)('0' + (a_cur / 100U) % 10U);
        st_dbg[3] = (char)('0' + (a_cur / 10U) % 10U);
        st_dbg[4] = (char)('0' + a_cur % 10U);
        st_dbg[5] = '\0';
        break;
    }
    case 3: {
        uint16_t b_cur = (uint16_t)(Signal_Processing_Get_Filtered_Code(ADC_TEMP_DIO_IDX) + 0.5f);
        if (b_cur > 9999U) b_cur = 9999U;
        st_dbg[0] = 'B';
        st_dbg[1] = (char)('0' + (b_cur / 1000U) % 10U);
        st_dbg[2] = (char)('0' + (b_cur / 100U) % 10U);
        st_dbg[3] = (char)('0' + (b_cur / 10U) % 10U);
        st_dbg[4] = (char)('0' + b_cur % 10U);
        st_dbg[5] = '\0';
        break;
    }
    case 4: {
        uint16_t f_cur = (uint16_t)(Signal_Processing_Get_Filtered_Code(ADC_FAN_CURR_IDX) + 0.5f);
        if (f_cur > 9999U) f_cur = 9999U;
        st_dbg[0] = 'F';
        st_dbg[1] = (char)('0' + (f_cur / 1000U) % 10U);
        st_dbg[2] = (char)('0' + (f_cur / 100U) % 10U);
        st_dbg[3] = (char)('0' + (f_cur / 10U) % 10U);
        st_dbg[4] = (char)('0' + f_cur % 10U);
        st_dbg[5] = '\0';
        break;
    }
    case 5: {
        uint16_t e_cur = (uint16_t)(Signal_Processing_Get_Filtered_Code(ADC_V15V_IDX) + 0.5f);
        if (e_cur > 9999U) e_cur = 9999U;
        st_dbg[0] = 'E';
        st_dbg[1] = (char)('0' + (e_cur / 1000U) % 10U);
        st_dbg[2] = (char)('0' + (e_cur / 100U) % 10U);
        st_dbg[3] = (char)('0' + (e_cur / 10U) % 10U);
        st_dbg[4] = (char)('0' + e_cur % 10U);
        st_dbg[5] = '\0';
        break;
    }
    default: {
        uint32_t ms = System_Get_Tick() % 100000U;
        st_dbg[0] = 'M';
        st_dbg[1] = (char)('0' + (ms / 10000U) % 10U);
        st_dbg[2] = (char)('0' + (ms / 1000U) % 10U);
        st_dbg[3] = (char)('0' + (ms / 100U) % 10U);
        st_dbg[4] = (char)('0' + (ms / 10U) % 10U);
        st_dbg[5] = (char)('0' + ms % 10U);
        st_dbg[6] = '\0';
        break;
    }
    }
    UI_PrintDiag(0, st_dbg);

    // 4. Асинхронный флип (подмена указателей), кадр мгновенно улетает по DMA
    OLED_Swap_Buffers();
}
